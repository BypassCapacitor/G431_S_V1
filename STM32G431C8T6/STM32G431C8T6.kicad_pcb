# Repository BypassCapacitor/G431_S_V1

File README.md:

# G431_S_V1
STM32G431C8T6 system board, temporarily designed for the 2024 Electronic Design Competition.

Bug_0722:
1. Package_error

  The pins 1 and 2 of the transistor package have an unknown error on the actual PCB, requiring the transistor to be soldered upside down.

## KiCad design STM32G431C8T6/STM32G431C8T6.kicad_pcb

Parts:
C3, C4, C6, C8, C10: 4.7uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5, C7, C9, C11, C14, C15, C16, C17: 100nf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C24: 470nf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D2, D3: 1N4007; D_SMA_Handsoldering
D5, D6, D8: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9: TVS; D_SMA_Handsoldering
FB1, FB2: FerriteBead_Small; Fuse_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R14, R15, R17: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U2, U3: AMS1117-3.3; SOT-223-3_TabPin2
U5: REF3033AIDBZR; SOT-23_Handsoldering

Connections:
+3.3V: C6.1, C7.1, C10.1, C11.1, C16.2, R17.2, U3.2 (VO); also elsewhere on the board
+3.3VFS: C4.1, C5.1, C8.1, C9.1, C17.1, U2.2 (VO); also elsewhere on the board
+3.3VRF: U5.2 (OUT); also elsewhere on the board
+5V: C3.2, C14.1, C15.2, C24.1, FB1.2, U2.3 (VI), U3.3 (VI), U5.1 (IN)
+5VL: D2.2 (A), R15.2; also elsewhere on the board
+5VP: D3.2 (A), R14.2; also elsewhere on the board
AGND: C3.1, D5.1 (K), D6.1 (K), D9.2 (A), FB2.1
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C14.2, C15.1, C16.1, C17.2, C24.2, D8.1 (K), FB2.2, U2.1 (GND), U3.1 (GND), U5.3 (GND); also elsewhere on the board
unnamed: D2.1 (K), D3.1 (K), D9.1 (K), FB1.1
unnamed: D5.2 (A), R14.1
unnamed: D6.2 (A), R15.1
unnamed: D8.2 (A), R17.1

Notes on the sheet:
供电部分
基准电平

Parts:
C1, C2: 22pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12: 100pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
J2: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical
J3: Conn_01x05_Pin; PinHeader_1x05_P2.54mm_Vertical
Q1: SS8050; SOT-23_Handsoldering
R1, R2, R6: 10; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 1.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 36k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11: 4.7K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R18, R21: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: STM32F103CBTx; LQFP-48_7x7mm_P0.5mm
Y1: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3.3VFS: J3.1, Q1.3 (C), R9.2, R10.2, R12.1, R18.1, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD); also elsewhere on the board
+5VL: J2.1, J2.2; also elsewhere on the board
+5VP: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), R4.2; also elsewhere on the board
/Debuger/AIN: R10.1, R11.2, U1.10 (PA0)
/Debuger/LED_STLINK: D1.1 (K), U1.30 (PA9)
/Debuger/STLINK_RX1: J2.13, U1.13 (PA3)
/Debuger/STLINK_TX1: J2.11, U1.12 (PA2)
/Debuger/ST_SWCLK: J3.3, U1.37 (PA14)
/Debuger/ST_SWDIO: J3.2, U1.34 (PA13)
/Debuger/T_JTCK: J2.8; also elsewhere on the board
/Debuger/T_JTCK1: J2.7, U1.15 (PA5), U1.26 (PB13)
/Debuger/T_JTMS: J2.6; also elsewhere on the board
/Debuger/T_JTMS1: J2.5, R19.1, U1.27 (PB14)
/Debuger/T_NRST1: J2.9, U1.18 (PB0)
/Debuger/T_SWDIOIN: R19.2, U1.25 (PB12)
/Debuger/USART2_RX: J2.14; also elsewhere on the board
/Debuger/USART2_TX: J2.12; also elsewhere on the board
/Debuger/USB_DN: R1.2, U1.32 (PA11)
/Debuger/USB_DP: R2.2, U1.33 (PA12)
/Debuger/USB_RENUMn: R6.2, U1.38 (PA15)
/Debuger/nrs: C12.1, J3.4, R12.2, U1.7 (NRST)
/MCU/RSET: J2.10; also elsewhere on the board
GND: C1.1, C2.1, C12.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.3, J2.4, J3.5, R5.1, R7.2, R8.2, R11.1, R21.1, U1.8 (VSSA), U1.20 (PB2), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), Y1.2, Y1.4; also elsewhere on the board
unnamed: D1.2 (A), R9.1
unnamed: J1.A5 (CC1), R7.1
unnamed: J1.B5 (CC2), R8.1
unnamed: J1.A6 (D+), J1.B6 (D+), R2.1, R3.1
unnamed: J1.A7 (D-), J1.B7 (D-), R1.1
unnamed: Q1.1 (B), R4.1, R5.2, R6.1
unnamed: Q1.2 (E), R3.2
unnamed: R21.2, U1.44 (BOOT0)
unnamed: R18.2, U1.39 (PB3)
unnamed: C1.2, U1.5 (PD0), Y1.3
unnamed: C2.2, U1.6 (PD1), Y1.1

Notes on the sheet:
连接跳帽
指示灯

Parts:
C13, C18, C19, C20, C21: 100pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22, C23: 22pf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D10: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D11: D; D_SMA_Handsoldering
J4, J5, J6, J7: Conn_Coaxial; SMA_Samtec_SMA-J-P-H-ST-EM1_EdgeMount
J8: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
J9, J10: Conn_02x12_Odd_Even; PinHeader_2x12_P2.54mm_Vertical
R20, R22, R23, R24, R25, R26: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R27: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2, SW3, SW4, SW5: SW_Push; SW_Tactile_SPST_NO_Straight_CK_PTS636Sx25SMTRLFS
U4: STM32G431C8Tx; LQFP-48_7x7mm_P0.5mm
Y2: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm_HandSoldering

Connections:
+3.3V: J8.3, J10.1, J10.2, J10.3, J10.4, R20.2, R22.2, R23.2, R24.2, R25.2, U4.1 (VBAT), U4.21 (VDDA), U4.24 (VDD), U4.36 (VDD), U4.48 (VDD); also elsewhere on the board
+3.3VFS: J9.1, J9.2, J9.3, J9.4; also elsewhere on the board
+3.3VRF: U4.20 (VREF+); also elsewhere on the board
/Debuger/T_JTCK: U4.38 (PA14); also elsewhere on the board
/Debuger/T_JTMS: U4.37 (PA13); also elsewhere on the board
/Debuger/USART2_RX: U4.32 (PA10); also elsewhere on the board
/Debuger/USART2_TX: U4.31 (PA9); also elsewhere on the board
/MCU/PA0: J4.1 (In), U4.8 (PA0)
/MCU/PA1: J5.1 (In), U4.9 (PA1)
/MCU/PA2: J9.14, U4.10 (PA2)
/MCU/PA3: J9.16, U4.11 (PA3)
/MCU/PA4: J6.1 (In), U4.12 (PA4)
/MCU/PA5: J7.1 (In), U4.13 (PA5)
/MCU/PA6: J9.22, U4.14 (PA6)
/MCU/PA7: J9.24, U4.15 (PA7)
/MCU/PA8: J10.10, U4.30 (PA8)
/MCU/PA11: J10.12, U4.33 (PA11)
/MCU/PA12: J10.14, U4.34 (PA12)
/MCU/PA15: J8.2, J10.16, U4.39 (PA15)
/MCU/PB0: J9.9, J9.10, U4.16 (PB0)
/MCU/PB1: J9.11, J9.12, U4.17 (PB1)
/MCU/PB2: J9.13, U4.18 (PB2)
/MCU/PB3: J9.15, U4.40 (PB3)
/MCU/PB4: J9.17, J9.18, U4.41 (PB4)
/MCU/PB5: J9.19, J9.20, U4.42 (PB5)
/MCU/PB6: J9.21, U4.43 (PB6)
/MCU/PB7: J8.1, J9.23, U4.44 (PB7)
/MCU/PB8: J10.9, R27.2, U4.45 (PB8)
/MCU/PB9: J10.11, U4.46 (PB9)
/MCU/PB10: J10.13, U4.22 (PB10)
/MCU/PB11: C18.2, J10.15, R22.1, SW2.1, U4.25 (PB11)
/MCU/PB12: C19.2, J10.17, R23.1, SW3.1, U4.26 (PB12)
/MCU/PB13: C20.2, J10.19, R24.1, SW4.1, U4.27 (PB13)
/MCU/PB14: C21.2, J10.21, R25.1, SW5.1, U4.28 (PB14)
/MCU/PB15: J10.23, R26.2, U4.29 (PB15)
/MCU/PC13: J10.18, U4.2 (PC13)
/MCU/PC14: J10.20, U4.3 (PC14)
/MCU/PC15: J10.22, U4.4 (PC15)
/MCU/RSET: C13.2, D11.1 (K), J10.24, R20.1, SW1.1, U4.7 (PG10); also elsewhere on the board
GND: C13.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, D10.1 (K), D11.2 (A), J4.2 (Ext), J5.2 (Ext), J6.2 (Ext), J7.2 (Ext), J8.4, J9.5, J9.6, J9.7, J9.8, J10.5, J10.6, J10.7, J10.8, R27.1, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, U4.19 (VSSA), U4.23 (VSS), U4.35 (VSS), U4.47 (VSS), Y2.2, Y2.4; also elsewhere on the board
unnamed: D10.2 (A), R26.1
unnamed: C22.2, U4.5 (PF0), Y2.3
unnamed: C23.2, U4.6 (PF1), Y2.1

Notes on the sheet:
VCC
ADC1
GND
DAC1
DAC2
SDA
ADC2
SCL

Board: 2 copper layers, 35.0 x 79.0 mm, 83 parts (4 on the bottom side), 76 nets.

## Code that names these connections

File stm32g431c8t6.ioc (part):

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Mcu.Name=STM32G431C(6-8-B)Tx
Mcu.Package=LQFP48
Mcu.UserName=STM32G431C8Tx
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA1.Mode=IN2-Single-Ended
PA1.Signal=ADC1_IN2
PA10.Mode=Asynchronous
PA10.Signal=USART1_RX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Mode=I2C
PA15.Signal=I2C1_SCL
PA4.Signal=COMP_DAC11_group
PA5.Signal=COMP_DAC12_group
PA9.Mode=Asynchronous
PA9.Signal=USART1_TX
PB11.Signal=GPIO_Input
PB12.Signal=GPIO_Input
PB13.Signal=GPIO_Input
PB14.Signal=GPIO_Input
PB15.Signal=GPIO_Output
PB7.Mode=I2C
PB7.Signal=I2C1_SDA
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

## Commit log

2024-07-24 Version1_complete
2024-07-24 Cubemx_I2C_repair
